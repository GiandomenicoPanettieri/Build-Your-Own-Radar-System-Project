options:
  parameters:
    generate_options: qt_gui
    id: SFCW_Test
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: TX_GAIN
  id: variable_qtgui_range
  parameters:
    start: '40'
    step: '5'
    stop: '90'
    value: '70'
  states: {}
- name: fc
  id: variable
  parameters:
    value: 5.8e9
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '44100'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_complex_to_float_0
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\panet\Desktop\RADAR PROJECT\REVIEW 5\REVIEW 5\Audios\RealPartCW.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: blocks_wavfile_sink_1
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\Users\panet\Desktop\RADAR PROJECT\REVIEW 5\REVIEW 5\Audios\ImaginaryPartCW.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: dc_blocker_xx_0_1_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: '10000'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_1
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: window.WIN_FLATTOP
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: TX_GAIN
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: fc
    gain0: '50'
    samp_rate: samp_rate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [blocks_complex_to_float_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_complex_to_float_0, '0', qtgui_waterfall_sink_x_1, '0']
- [blocks_complex_to_float_0, '1', blocks_wavfile_sink_1, '0']
- [dc_blocker_xx_0_1_0, '0', filter_fft_low_pass_filter_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_complex_to_float_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0_1_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.6.0
